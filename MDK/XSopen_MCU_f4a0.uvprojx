# Keil uVision project XSopen_MCU_f4a0.uvprojx, settings and files
target hc32f4a0_template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.7
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XSopen_MCU_f4a0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,F4A0_HCLK_VALUE_MAX
  c include: ..\Bsp\inc;..\Cmsis;..\App;..\Drivers\inc;..\Drivers;..\Components\device\led;..\Components\peripheral\wdt;..\Obj_Manage;..\Components\device\at24c02;..\Components\device\TFcard;..\Middlewares\Fatfs;..\Components\device\w25q64;..\Components\device\LCD\ILI9341;..\Components\device\SRAM;..\Middlewares\FreeRTOS\inc;..\Middlewares\FreeRTOS\conf;..\Middlewares\FreeRTOS\port;..\Middlewares\DLT645_Master\Include;..\Middlewares\Lwip\LwIP\include;..\Middlewares\Lwip\LwIP\config;..\Middlewares\Lwip\LwIP\port;..\Middlewares\Lwip\LwIP\port;..\EV_BOARD;..\Components\device\tca9839;..\net;..\Task\Remote;..\Task\Control;..\Task\Storage;..\Task\HMI;..\Middlewares\DLT645_Master\Portable
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  group BOOT
    ../BOOT/: startup_hc32f4a0.s system_hc32f4a0.c
  group CMSIS
    ../Cmsis/: core_cm4.h cmsis_armcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h systick.c
  group Drivers
    ../Drivers/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_ctc.c hc32_ll_dac.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_dmc.c hc32_ll_dvp.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_eth.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_fmac.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_hrpwm.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mau.c hc32_ll_mpu.c hc32_ll_nfc.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_smc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr2.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32f4a0_ll_interrupts_share.c
    ../Drivers/: hc32f4a0.h hc32f4xx.h system_hc32f4a0.h hc32f4xx_conf.h
  group BSP
    ../Bsp/src/: bsp_gpio.c bsp_wdt.c bsp_uart.c bsp_timer0.c bsp_extint_key.c bsp_i2c.c bsp_dma.c bsp_rtc.c bsp_spi.c bsp_ots.c bsp_gpport.c bsp_timer2.c bsp_sdio.c bsp_dac.c
  group EV_BOARD
    ../EV_BOARD/: ev_hc32f4a0_lqfp176.c
  group Components/peripheral
    ../Components/peripheral/wdt/: wdt.c
  group Components/devide
    ../Components/device/led/: led.c
    ../Components/device/at24c02/: at24cxx.c
    ../Components/device/TFcard/: sd.c
    ../Components/device/w25q64/: w25qxx.c
    ../Components/device/LCD/ILI9341/: ili9341.c
    ../Components/device/SRAM/: is62wv51216.c
    ../Components/device/tca9839/: ev_hc32f4a0_lqfp176_tca9539.c tca9539.c
  group Obj_Manage
    ../Obj_Manage/: obj_mem_malloc.c usr_list.c
  group Middlewares/Fatfs
    ../Middlewares/Fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group Middlewares/FreeRTOS/Source
    ../Middlewares/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/Ports
    ../Middlewares/FreeRTOS/port/: heap_4.c port.c portmacro.h
  group Middlewares/FreeRTOS/Config
    ../Middlewares/FreeRTOS/conf/: FreeRTOSConfig.h
  group Middlewares/LwIP/api
    ../Middlewares/Lwip/LwIP/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/core
    ../Middlewares/Lwip/LwIP/core/: autoip.c def.c dhcp.c dns.c etharp.c icmp.c igmp.c inet_chksum.c init.c ip.c ip4.c ip4_addr.c ip4_frag.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/netif
    ../Middlewares/Lwip/LwIP/netif/: ethernet.c lowpan6.c
  group Middlewares/LwIP/port
    ../Middlewares/Lwip/LwIP/port/arch/: bpstruct.h cc.h epstruct.h perf.h sys_arch.h
    ../Middlewares/Lwip/LwIP/port/: ethernetif.c
  group Middlewares/LwIP/config
    ../Middlewares/Lwip/LwIP/config/: lwipopts.h
  group Middlewares/DLT645_Master
    ../Middlewares/DLT645_Master/Source/: dlt645.c dlt645_data.c
    ../Middlewares/DLT645_Master/Portable/: d_port.c
    ../Middlewares/DLT645_Master/Include/: dlt645conf.h
  group Net
    ../net/: udp_echo.c tcp_echo.c
  group Usr_lib
    ../Usr_lib/: common.c crc.c
  group Task/Control
    ../Task/Control/: Task_LED.c
  group Task/Remote
    ../Task/Remote/: task_remote.c
  group App
    ../App/: main.c
  group Doc
    ../Doc/: 通用工程初次编译错误解决方案.txt 版本说明.txt 笔记.txt 测试手册.txt
software components: CMSIS:CORE 5.4.0
